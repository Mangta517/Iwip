# Keil uVision project lwip.uvprojx, settings and files
target lwip (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: lwip +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F;../Middlewares/Iwip;../Middlewares/Iwip/arch;../Middlewares/Iwip/src/include;../Drivers;../Drivers/BSP/ETHERNET;../Drivers/BSP/lcd;../Drivers/BSP/touch;../Drivers/BSP/font;../Drivers/BSP/flash;../Drivers/BSP/sdram;../Drivers/BSP/led;../Drivers/BSP;../application
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Startup
    ./: startup_stm32f407xx.s
  group Core/Inc
    ../Core/Inc/: gpio.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h usart.h
  group Core/Src
    ../Core/Src/: gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group Drivers/BSP/ETHERNET
    ../Drivers/BSP/ETHERNET/: ethernet.c ethernet.h ethernet_chip.c ethernet_chip.h
  group Drivers/BSP/lcd
    ../Drivers/BSP/lcd/: bsp_nt35510_lcd.c bsp_nt35510_lcd.h
  group Drivers/BSP/touch
    ../Drivers/BSP/touch/: bsp_i2c_touch.c bsp_i2c_touch.h gt5xx.c gt5xx.h palette.c palette.h
  group Drivers/BSP/font
    ../Drivers/BSP/font/: fonts.c fonts.h
  group Drivers/BSP/flash
    ../Drivers/BSP/flash/: bsp_spi_flash.c bsp_spi_flash.h
  group Drivers/BSP/sdram
    ../Drivers/BSP/sdram/: bsp_sdram.c bsp_sdram.h
  group Drivers/BSP/led
    ../Drivers/BSP/led/: bsp_led.c bsp_led.h
  group Middlewares/Iwip/arch
    ../Middlewares/Iwip/arch/: cc.h ethernetif.c ethernetif.h lwip_comm.c lwip_comm.h lwipopts.h sys_arch.c sys_arch.h
  group Middlewares/Iwip/src/api
    ../Middlewares/Iwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Iwip/src/core
    ../Middlewares/Iwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Iwip/src/core/ipv4
    ../Middlewares/Iwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Iwip/src/core/ipv6
    ../Middlewares/Iwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Middlewares/Iwip/src/netif
    ../Middlewares/Iwip/src/netif/: ethernet.c
  group application
    ../application/: app_task.c app_task.h
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/include/: FreeRTOSConfig.h
    ../Middlewares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Readme
    ../: README-lwIP.md
software components: CMSIS:CORE 4.3.0
